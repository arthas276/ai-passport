#include "slang_core.h"

#include <string.h>

/* 离线缩小版。每条都是给这块屏写的短说明，不是某本现成词典的摘录。
 * 只收仍常见、三键也能翻到的说法，不追当天热搜。 */

static const slang_entry_t ENTRIES[] = {
    {"YYDS", "永远的神", "yyds", "永远的神", "把喜欢的人或东西抬到顶。"},
    {"绝绝子", "绝绝子", "jjz", "绝了再加一层", "夸到词穷，也能带点玩笑。"},
    {"破防", "破防", "pf", "防线破了", "被一句话或一段内容击中。"},
    {"DNA动了", "DNA动了", "dnadl", "基因动了", "被熟悉的东西瞬间抓住。"},
    {"上头", "上头", "st", "上头", "越看越停不下来。"},
    {"下头", "下头", "xt", "下头", "刚才的好感突然掉下去。"},
    {"真香", "真香", "zx", "真香", "刚拒绝，转头就接受。"},
    {"真的会谢", "真的会谢", "zdhx", "真的会谢", "表面道谢，语气其实在吐槽。"},
    {"笑死", "笑死", "xs", "笑死", "觉得很好笑，不是真出事。"},
    {"笑不活了", "笑不活了", "xbhl", "笑不活了", "笑到夸张，常当回复。"},
    {"蚌埠住了", "蚌埠住了", "bbzl", "绷不住了", "谐音，快要笑出声或露馅。"},
    {"栓Q", "栓Q", "sq", "谢谢", "谢谢的玩笑写法。"},
    {"退退退", "退退退", "ttt", "退退退", "想把倒霉事赶开。"},
    {"我真的会谢", "我真的会谢", "wzdhx", "我真的会谢", "无奈地道谢，多半是吐槽。"},
    {"我裂开了", "我裂开了", "wlkl", "我裂开了", "被结果气到或无语。"},
    {"我酸了", "我酸了", "wsl", "我酸了", "坦白羡慕。"},
    {"我服了", "我服了", "wfl", "我服了", "无语到认输。"},
    {"我哭了", "我哭了", "wkl", "我哭了", "被感动，也能是被气笑。"},
    {"我直接好了", "我直接好了", "wzjhl", "我直接好了", "听完一段话，心情突然转好。"},
    {"我不理解", "我不理解", "wblj", "我不理解", "看不懂对方为什么这样。"},
    {"我不服", "我不服", "wbf", "我不服", "结果不认，还想再试。"},
    {"我不李姐", "我不李姐", "wblj", "我不理解", "我不理解的谐音玩笑。"},
    {"我可以", "我可以", "wky", "我可以", "自我打气，也可以接一句离谱计划。"},
    {"我不ok", "我不OK", "wbok", "我不接受", "明确拒绝，语气偏轻。"},
    {"芭比Q了", "芭比Q了", "bbql", "完了", "事情砸了，谐音barbecue。"},
    {"寄了", "寄了", "jl", "完了", "计划失败，口气很短。"},
    {"完了", "完了", "wl", "完了", "预感到要出问题。"},
    {"寄", "寄", "j", "失败", "最短的失败评价。"},
    {"翻车", "翻车", "fc", "翻车", "公开场合没发挥好。"},
    {"社死", "社死", "ss", "社会性死亡", "当场尴尬到想消失。"},
    {"尴尬癌", "尴尬癌", "gga", "怕尴尬", "一点尴尬就浑身不自在。"},
    {"脚趾抠地", "脚趾抠地", "jzkd", "脚趾抠地", "替人尴尬。"},
    {"地面坍缩", "地面坍缩", "dmts", "地面坍缩", "尴尬到地面都开了。"},
    {"人麻了", "人麻了", "rml", "人麻了", "无语到没反应。"},
    {"麻了", "麻了", "ml", "麻了", "见多了，已经不吃惊。"},
    {"无语", "无语", "wy", "无语", "不知该回什么。"},
    {"无语子", "无语子", "wyz", "无语", "把无语说软一点。"},
    {"逆天", "逆天", "nt", "逆天", "离谱到超常，可夸可骂。"},
    {"离大谱", "离大谱", "ldp", "离谱", "离谱的玩笑写法。"},
    {"离谱", "离谱", "lp", "离谱", "超出正常预期。"},
    {"抽象", "抽象", "cx", "抽象", "怪、乱，但又有点好笑。"},
    {"整活", "整活", "zh", "整活", "故意做一段有节目效果的事。"},
    {"搞事", "搞事", "gs", "搞事", "主动挑起一点热闹。"},
    {"整挺好", "整挺好", "zth", "整挺好", "看着乱七八糟，结果居然不错。"},
    {"草", "草", "c", "震惊", "被惊到的一声，常单独发。"},
    {"草率了", "草率了", "csl", "草率了", "刚才判断太快。"},
    {"确实", "确实", "qs", "确实", "表示同意，也可单独回复。"},
    {"好家伙", "好家伙", "hjh", "好家伙", "吃惊，不一定是夸。"},
    {"好活", "好活", "hh", "好活", "这段表现有意思。"},
    {"典", "典", "d", "很典型", "这反应太常见了。"},
    {"孝", "孝", "x", "好孝顺", "调侃很听某人的话。"},
    {"乐", "乐", "l", "好笑", "觉得有趣，也可以是幸灾乐祸。"},
    {"急了", "急了", "jl", "急了", "对方开始沉不住气。"},
    {"破大防", "破大防", "pdf", "破防", "比普通破防更严重。"},
    {"精神状态", "精神状态", "jszt", "精神状态", "调侃状态不稳定。"},
    {"精神内耗", "精神内耗", "jsnh", "精神内耗", "自己跟自己过不去。"},
    {"CPU我", "CPU我", "cpuw", "拿我运算", "觉得被拿来分析或操控。"},
    {"PUA", "PUA", "pua", "打压再抬", "先贬低再给一点点肯定。"},
    {"画饼", "画饼", "hb", "画饼", "承诺很大，兑现未知。"},
    {"甩锅", "甩锅", "sg", "甩锅", "把责任推给别人。"},
    {"背锅", "背锅", "bg", "背锅", "替别人承担后果。"},
    {"内卷", "内卷", "nj", "内卷", "大家都加码，收益却没增加。"},
    {"躺平", "躺平", "tp", "躺平", "不再跟着卷。"},
    {"摆烂", "摆烂", "bl", "摆烂", "已知要差，索性不补。"},
    {"卷王", "卷王", "jw", "卷王", "最能加码的那个人。"},
    {"摸鱼", "摸鱼", "my", "摸鱼", "上班或上课时偷偷休息。"},
    {"班味", "班味", "bw", "班味", "长期上班留下的疲惫感。"},
    {"打工人", "打工人", "dgr", "打工人", "自嘲靠上班过活。"},
    {"干饭人", "干饭人", "gfr", "干饭人", "把吃饭当成一件正经事。"},
    {"尾款人", "尾款人", "wkr", "尾款人", "还在还预售或分期的人。"},
    {"省流", "省流", "sl", "省流", "直接给结论，不用看全文。"},
    {"划重点", "划重点", "hzd", "划重点", "提醒只看这一句。"},
    {"先说结论", "先说结论", "xsjl", "先说结论", "把结果放在最前面。"},
    {"看不懂但大为震撼", "看不懂但大为震撼", "kbddwzh", "看不懂但震撼", "没完全懂，仍然被震住。"},
    {"已读不回", "已读不回", "ydbh", "已读不回", "看了消息，却不回复。"},
    {"已读乱回", "已读乱回", "ydlh", "已读乱回", "回了，但没接上话题。"},
    {"空耳", "空耳", "ke", "空耳", "按听到的音乱写成另几个字。"},
    {"玩梗", "玩梗", "wg", "玩梗", "把一句现成说法拿来用。"},
    {"接梗", "接梗", "jg", "接梗", "顺着别人的玩笑往下说。"},
    {"烂梗", "烂梗", "lg", "烂梗", "用太多次，已经不好笑。"},
    {"冷梗", "冷梗", "lg", "冷梗", "知道的人不多，现场容易冷掉。"},
    {"名场面", "名场面", "mcm", "名场面", "会被反复提起的一段。"},
    {"高光", "高光", "gg", "高光", "表现最好的那一下。"},
    {"翻红", "翻红", "fh", "翻红", "旧内容又被人拿出来。"},
    {"过气", "过气", "gq", "过气", "以前很火，现在少人提。"},
    {"长尾", "长尾", "cw", "长尾", "热度过后仍有人记得。"},
    {"出圈", "出圈", "cq", "出圈", "从小圈子传到更多人那里。"},
    {"入坑", "入坑", "rk", "入坑", "开始认真喜欢一件事。"},
    {"退坑", "退坑", "tk", "退坑", "不再追这件事。"},
    {"粉了", "粉了", "fl", "粉了", "开始喜欢。"},
    {"路人", "路人", "lr", "路人", "不站队，只是看见了。"},
    {"黑粉", "黑粉", "hf", "黑粉", "持续关注，但主要是批评。"},
    {"唯粉", "唯粉", "wf", "唯粉", "只支持其中一个人。"},
    {"团粉", "团粉", "tf", "团粉", "支持整个组合。"},
    {"恋爱脑", "恋爱脑", "lan", "恋爱脑", "遇事先从感情角度想。"},
    {"事业脑", "事业脑", "syn", "事业脑", "遇事先想工作和成果。"},
    {"选择困难", "选择困难", "xzn", "选择困难", "几个选项都能耗很久。"},
    {"电子榨菜", "电子榨菜", "dzzc", "下饭内容", "吃饭时放来看的轻松内容。"},
    {"下饭", "下饭", "xf", "下饭", "看着不费劲，适合配饭。"},
    {"电子宠物", "电子宠物", "dzcw", "电子宠物", "屏幕里的陪伴，不是真动物。"},
    {"赛博", "赛博", "sb", "赛博", "强调这件事发生在网上。"},
    {"网上冲浪", "网上冲浪", "wscs", "网上冲浪", "随便浏览各处内容。"},
    {"信息差", "信息差", "xxc", "信息差", "有人知道，有人还不知道。"},
    {"滤镜", "滤镜", "lj", "滤镜", "把真人修得很不一样。"},
    {"素颜", "素颜", "sy", "素颜", "没怎么修饰的样子。"},
    {"营业", "营业", "yy", "营业", "按粉丝期待出现或更新。"},
    {"放假", "放假", "fj", "放假", "在粉丝语境里也可指暂时不更新。"},
    {"塌房", "塌房", "tf", "塌房", "喜欢的人突然爆出严重问题。"},
    {"洗白", "洗白", "xb", "洗白", "试图把不好的事说过去。"},
    {"澄清", "澄清", "cq", "澄清", "出来说明某个传闻不实。"},
    {"实锤", "实锤", "sc", "实锤", "证据已经比较硬。"},
    {"锤", "锤", "c", "证据", "拿得出的证据。"},
    {"瓜", "瓜", "g", "瓜", "正在传的新鲜事。"},
    {"吃瓜", "吃瓜", "cg", "吃瓜", "围观，先不站队。"},
    {"瓜田", "瓜田", "gt", "瓜田", "消息集中出现的地方。"},
    {"前端时间", "前端时间", "qdsj", "前段时间", "谐音错写，常被当玩笑留下。"},
    {"柠檬精", "柠檬精", "nmj", "柠檬精", "很酸，也就是很羡慕。"},
    {"酸了", "酸了", "sl", "酸了", "承认羡慕。"},
    {"慕了", "慕了", "ml", "慕了", "羡慕的轻说法。"},
    {"泪目", "泪目", "lm", "泪目", "快要被感动哭。"},
    {"破防了", "破防了", "pfl", "破防了", "已经受影响，不只是看见。"},
    {"刀了", "刀了", "dl", "刀了", "被剧情或消息伤到。"},
    {"刀子", "刀子", "dz", "刀子", "容易让人难受的一段。"},
    {"发糖", "发糖", "ft", "发糖", "给一段让人高兴的互动。"},
    {"撒糖", "撒糖", "st", "撒糖", "主动放出甜的内容。"},
    {"磕到了", "磕到了", "kdl", "磕到了", "从互动里看出了感情线。"},
    {"嗑cp", "嗑CP", "kcp", "喜欢一对组合", "把两个人的互动当一对来看。"},
    {"拉郎", "拉郎", "ll", "拉郎", "把原本不配对的人凑成一对。"},
    {"产品", "产品", "cp", "一对组合", "这里多指CP，不是商品。"},
    {"官宣", "官宣", "gx", "官宣", "由本人或机构正式公布。"},
    {"暗宣", "暗宣", "ax", "暗宣", "没直说，但放了足够的暗示。"},
    {"营业式发糖", "营业式发糖", "yysft", "营业式发糖", "像完成任务一样放出互动。"},
    {"人设", "人设", "rs", "人设", "对外维持的形象。"},
    {"崩人设", "崩人设", "brs", "崩人设", "表现和原有形象对不上。"},
    {"立flag", "立flag", "lflag", "立下预言", "说了一句很容易被打脸的话。"},
    {"打脸", "打脸", "dl", "打脸", "后来的事实推翻了原话。"},
    {"当场去世", "当场去世", "dcqs", "当场去世", "夸张地说自己受不了。"},
    {"我没了", "我没了", "wml", "我没了", "被可爱或好笑的东西击中。"},
    {"这是可以的", "这是可以的", "zskyd", "这是可以的", "认可，语气偏淡。"},
    {"也不是不行", "也不是不行", "ybsbx", "也不是不行", "勉强接受。"},
    {"有一说一", "有一说一", "yysy", "有一说一", "准备说句相对老实的话。"},
    {"不是吧", "不是吧", "bsb", "不是吧", "不愿相信刚看到的结果。"},
    {"不是哥们", "不是哥们", "bsgm", "不是哥们", "对熟人突然做出的事表示震惊。"},
    {"你人还怪好的", "你人还怪好的", "nrhghd", "你人还怪好的", "带笑夸一句，常接在互助后。"},
    {"格局打开", "格局打开", "gjdk", "格局打开", "叫人别只盯眼前得失。"},
    {"格局小了", "格局小了", "gjxl", "格局小了", "觉得对方想得太窄。"},
    {"版本答案", "版本答案", "bbda", "版本答案", "当前最有效的做法。"},
    {"最优解", "最优解", "zyj", "最优解", "眼下看起来最好的选择。"},
    {"正确的", "正确的", "zqd", "正确的", "表示认可这套做法。"},
    {"有点东西", "有点东西", "ydds", "有点东西", "认可对方有两下。"},
    {"有点子东西", "有点子东西", "ydzds", "有点东西", "比上一句更口语。"},
    {"会说话", "会说话", "hsh", "会说话", "夸这句说得体面。"},
    {"会来事", "会来事", "hls", "会来事", "懂得把场面处理圆。"},
    {"太会了", "太会了", "thl", "太会了", "觉得对方很懂怎么做。"},
    {"主打一个", "主打一个", "zdyg", "主打一个", "后面接这件事最突出的特点。"},
    {"拿捏", "拿捏", "nn", "拿捏", "掌握得很稳。"},
    {"轻松拿捏", "轻松拿捏", "qsnn", "轻松拿捏", "觉得自己能处理好。"},
    {"被拿捏", "被拿捏", "bnn", "被拿捏", "自己的反应都被对方料到。"},
    {"已老实求放过", "已老实求放过", "ylsqfg", "已老实求放过", "被整蛊或被教育之后认输。"},
    {"放过我", "放过我", "fgw", "放过我", "求对方别再继续。"},
};

#define ENTRY_COUNT ((uint16_t)(sizeof(ENTRIES) / sizeof(ENTRIES[0])))

static char lower_ascii(char ch) {
    if (ch >= 'A' && ch <= 'Z') return (char)(ch - 'A' + 'a');
    return ch;
}

static bool contains_ci(const char *text, const char *query) {
    if (!text || !query || !query[0]) return false;
    size_t qlen = strlen(query);
    for (const char *cursor = text; *cursor; ++cursor) {
        size_t i = 0;
        while (query[i] && lower_ascii(cursor[i]) == lower_ascii(query[i])) ++i;
        if (i == qlen) return true;
        /* 中文按字节前进即可：查询已是完整 UTF-8，错位不会假匹配。 */
        if ((unsigned char)*cursor < 0x80u) continue;
    }
    return false;
}

uint16_t slang_count(void) {
    return ENTRY_COUNT;
}

const slang_entry_t *slang_at(uint16_t index) {
    if (index >= ENTRY_COUNT) return NULL;
    return &ENTRIES[index];
}

bool slang_query_ok(const char *query) {
    if (!query) return false;
    size_t len = 0;
    for (const unsigned char *cursor = (const unsigned char *)query; *cursor; ++cursor) {
        if (++len > SLANG_QUERY_MAX) return false;
        if (*cursor < 0x20u || *cursor == 0x7Fu) return false;
    }
    return true;
}

uint16_t slang_search(const char *query, uint16_t *out, uint16_t cap) {
    if (!out || !cap || !slang_query_ok(query) || !query[0]) return 0u;
    uint16_t found = 0u;
    for (uint16_t i = 0; i < ENTRY_COUNT && found < cap; ++i) {
        const slang_entry_t *entry = &ENTRIES[i];
        if (contains_ci(entry->title, query) || contains_ci(entry->pinyin, query) ||
            contains_ci(entry->reading, query) || contains_ci(entry->gloss, query)) {
            out[found++] = i;
        }
    }
    return found;
}

uint16_t slang_by_initial(char letter, uint16_t *out, uint16_t cap) {
    if (!out || !cap) return 0u;
    char key = lower_ascii(letter);
    if (key < 'a' || key > 'z') return 0u;
    uint16_t found = 0u;
    for (uint16_t i = 0; i < ENTRY_COUNT && found < cap; ++i) {
        if (lower_ascii(ENTRIES[i].pinyin[0]) == key) out[found++] = i;
    }
    return found;
}
